# Keil uVision project EDP.uvprojx, settings and files
target 接收端 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 接收端 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Common;..\CORE;..\ESP8266;..\STM32\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\EDP;..\TIM;..\HARDWARE\LED;..\SYSTEM\delay;..\HARDWARE\oled;..\HARDWARE\font;..\HARDWARE\OLED_Screen;..\HARDWARE\dht11;..\HARDWARE\lcd;..\HARDWARE\TIMER;..\HARDWARE\USART3;..\LORA;..\USER;..\HARDWARE\ds1302
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ./: main.c system_stm32f10x.c stm32f10x_it.c
  group Core
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group STM32_Lib
    ../STM32/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_fsmc.c
  group HardWare
    ../HARDWARE/LED/: led.c
    ../HARDWARE/dht11/: dht11.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ds1302/: DS1302.c DS1302.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group ESP8266
    ../ESP8266/: esp8266.c
  group EDP
    ../EDP/: EdpKit.c onenet.c
    ./: codeGraph.h
  group TIM
    ../TIM/: Tim.c
  group OLED_Screen
    ../HARDWARE/OLED_Screen/: Font.c Font.h OLED_Screen.c OLED_Screen.h OLED_Screen_para.h OLED_Screen_rule.h Pictures.c Pictures.h 说明.txt
  group LORA
    ../LORA/: lora_app.c lora_ui.c lora_cfg.h
